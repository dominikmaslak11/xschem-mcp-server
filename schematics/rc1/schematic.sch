v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {vsource.sym} 0 0 0 0 {name=V1 value="AC 1"}
C {gnd.sym} 0 -30 0 0 {name=lg1}
C {lab_pin.sym} 0 30 0 0 {name=l2 lab=in sig_type=std_logic}
C {res.sym} 150 0 0 0 {name=R1 value=1k}
C {lab_pin.sym} 150 -30 0 0 {name=l3 lab=in sig_type=std_logic}
C {lab_pin.sym} 150 30 0 0 {name=l4 lab=out sig_type=std_logic}
C {capa.sym} 300 0 0 0 {name=C1 value=100n}
C {lab_pin.sym} 300 -30 0 0 {name=l5 lab=out sig_type=std_logic}
C {gnd.sym} 300 30 0 0 {name=lg6}
